# linux-renesas_5.10.bbappend

KERNEL_MODULE_AUTOLOAD += "libarc4 cfg80211 mac80211"
KERNEL_MODULE_PROBECONF += "libarc4 cfg80211 mac80211"
