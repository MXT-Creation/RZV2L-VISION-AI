
IMAGE_INSTALL_append = " \
	packagegroup-gstreamer1.0-plugins \
	packagegroup-multimedia-libs \
	packagegroup-multimedia-kernel-modules \
	custom-configs \
	app-usbcam-http \
	app-usbcam-client \
	etb \
	ustreamer \
	iperf3 \
"
