FILESEXTRAPATHS_prepend := "${THISDIR}/2021.10:"

SRC_URI_append = "\
 	file://patch_uboot_px4.patch \
"

